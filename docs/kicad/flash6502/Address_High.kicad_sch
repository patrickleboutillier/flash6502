File: docs/kicad/flash6502/Address_High.kicad_sch (KiCad schematic)
At the start: 5 parts

Commit message: ok
Other:
- moved on the sheet: EAH, PCH_1, PCH_2, PCH_OUT, SPH_OUT

File: docs/kicad/flash6502/Address_Low.kicad_sch (KiCad schematic)
At the start: 7 parts

Commit message: ok
Other:
- moved on the sheet: PCL_1, PCL_2, PCL_OUT
